# Keil uVision project hello_world_test.uvprojx, settings and files
target hello_world_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: hello_world_test +hex
  AfterMake: fromelf --bin .\Objects\hello_world_test.axf -o .\Objects\hello_world_test.bin
  AfterMake: fromelf -cvf .\Objects\hello_world_test.axf -o .\Objects\disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: hello_world_test.c
  group drv
    ../../: cm0dsasm.s retarget.c
