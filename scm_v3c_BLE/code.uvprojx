# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPILER5)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: code
  AfterMake: fromelf --bin code.axf -o code.bin
  AfterMake: fromelf -cvf code.axf -o disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: cm0dsasm.s Int_Handlers.h main.c Memory_Map.h retarget.c rf_global_vars.h
    ./: scm3C_hardware_interface.c scm3C_hardware_interface.h scm3_hardware_interface.c scm3_hardware_interface.h scum_radio_bsp.c scum_radio_bsp.h scm_ble_functions.c scm_ble_functions.h
